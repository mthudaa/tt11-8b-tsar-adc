v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {nooverlap.sym} 390 -480 0 0 {name=x1}
C {bsw.sym} 390 -330 0 0 {name=x2}
C {tg_sw.sym} 390 -170 0 0 {name=x3}
C {devices/lab_wire.sym} 240 -470 0 0 {name=p3 sig_type=std_logic lab=CF}
C {devices/lab_wire.sym} 240 -510 0 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 240 -490 0 0 {name=p2 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 240 -370 0 0 {name=p4 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 240 -350 0 0 {name=p5 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 240 -210 0 0 {name=p6 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 240 -190 0 0 {name=p7 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 240 -330 0 0 {name=p8 sig_type=std_logic lab=SW}
C {devices/lab_wire.sym} 240 -310 0 0 {name=p9 sig_type=std_logic lab=CKB}
C {devices/lab_wire.sym} 240 -290 0 0 {name=p10 sig_type=std_logic lab=CK}
C {devices/lab_wire.sym} 240 -130 0 0 {name=p11 sig_type=std_logic lab=CKCMB}
C {devices/lab_wire.sym} 240 -150 0 0 {name=p12 sig_type=std_logic lab=CKCM}
C {devices/lab_wire.sym} 240 -170 0 0 {name=p13 sig_type=std_logic lab=VCM}
C {devices/lab_wire.sym} 540 -510 0 1 {name=p14 sig_type=std_logic lab=CK}
C {devices/lab_wire.sym} 540 -490 0 1 {name=p15 sig_type=std_logic lab=CKB}
C {devices/lab_wire.sym} 540 -470 0 1 {name=p16 sig_type=std_logic lab=CKCM}
C {devices/lab_wire.sym} 540 -450 0 1 {name=p17 sig_type=std_logic lab=CKCMB}
C {devices/lab_wire.sym} 540 -210 0 1 {name=p19 sig_type=std_logic lab=OUT}
C {devices/ipin.sym} 80 -500 0 0 {name=p20 sig_type=std_logic lab=VDD}
C {devices/ipin.sym} 80 -480 0 0 {name=p21 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 80 -440 0 0 {name=p22 sig_type=std_logic lab=CF}
C {devices/ipin.sym} 80 -420 0 0 {name=p23 sig_type=std_logic lab=SW}
C {devices/ipin.sym} 80 -460 0 0 {name=p24 sig_type=std_logic lab=VCM}
C {devices/opin.sym} 80 -380 0 0 {name=p25 sig_type=std_logic lab=OUT}
C {devices/lab_wire.sym} 540 -370 0 1 {name=p18 sig_type=std_logic lab=OUT}

v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {cdac.sym} 520 -520 0 0 {name=x2}
C {th_dif_sw.sym} 520 -240 0 0 {name=x3}
C {devices/lab_wire.sym} 670 -80 0 1 {name=p20 sig_type=std_logic lab=SWP[0:7]}
C {devices/lab_wire.sym} 670 -60 0 1 {name=p22 sig_type=std_logic lab=SWN[0:7]}
C {devices/lab_wire.sym} 670 -40 0 1 {name=p23 sig_type=std_logic lab=DOUT[0:7]}
C {devices/lab_wire.sym} 670 -20 0 1 {name=p24 sig_type=std_logic lab=CKO}
C {devices/lab_wire.sym} 670 -120 0 1 {name=p12 sig_type=std_logic lab=CKSB}
C {devices/lab_wire.sym} 670 -140 0 1 {name=p13 sig_type=std_logic lab=CKS}
C {devices/lab_wire.sym} 370 -230 0 0 {name=p1 sig_type=std_logic lab=CKSB}
C {devices/lab_wire.sym} 370 -250 0 0 {name=p2 sig_type=std_logic lab=CKS}
C {devices/lab_wire.sym} 370 -140 0 0 {name=p7 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 370 -120 0 0 {name=p3 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 370 -80 0 0 {name=p9 sig_type=std_logic lab=RDY}
C {devices/lab_wire.sym} 370 -60 0 0 {name=p28 sig_type=std_logic lab=CMP_P}
C {devices/lab_wire.sym} 370 -40 0 0 {name=p29 sig_type=std_logic lab=CMP_N}
C {devices/lab_wire.sym} 670 -420 0 1 {name=p4 sig_type=std_logic lab=CMP_P}
C {devices/lab_wire.sym} 670 -400 0 1 {name=p5 sig_type=std_logic lab=CMP_N}
C {devices/lab_wire.sym} 370 -210 0 0 {name=p6 sig_type=std_logic lab=VINP}
C {devices/lab_wire.sym} 370 -190 0 0 {name=p8 sig_type=std_logic lab=VINN}
C {devices/lab_wire.sym} 670 -290 0 1 {name=p10 sig_type=std_logic lab=VCP}
C {devices/lab_wire.sym} 670 -270 0 1 {name=p11 sig_type=std_logic lab=VCN}
C {devices/lab_wire.sym} 370 -360 0 0 {name=p14 sig_type=std_logic lab=VCP}
C {devices/lab_wire.sym} 370 -340 0 0 {name=p15 sig_type=std_logic lab=VCN}
C {devices/lab_wire.sym} 670 -570 0 1 {name=p16 sig_type=std_logic lab=VCP}
C {devices/lab_wire.sym} 670 -550 0 1 {name=p17 sig_type=std_logic lab=VCN}
C {devices/lab_wire.sym} 370 -490 0 0 {name=p18 sig_type=std_logic lab=SWP[0:7]}
C {devices/lab_wire.sym} 370 -470 0 0 {name=p19 sig_type=std_logic lab=SWN[0:7]}
C {devices/lab_wire.sym} 370 -510 0 0 {name=p21 sig_type=std_logic lab=CF[0:7]}
C {devices/lab_wire.sym} 370 -290 0 0 {name=p25 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 370 -270 0 0 {name=p26 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 370 -400 0 0 {name=p27 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 370 -380 0 0 {name=p30 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 370 -420 0 0 {name=p31 sig_type=std_logic lab=CLK}
C {devices/lab_wire.sym} 370 -570 0 0 {name=p32 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 370 -550 0 0 {name=p33 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 370 -530 0 0 {name=p36 sig_type=std_logic lab=VCM}
C {devices/ipin.sym} 120 -580 0 0 {name=p38 sig_type=std_logic lab=VDD}
C {devices/ipin.sym} 120 -560 0 0 {name=p39 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 120 -540 0 0 {name=p40 sig_type=std_logic lab=CLK}
C {devices/ipin.sym} 120 -520 0 0 {name=p41 sig_type=std_logic lab=VINP}
C {devices/ipin.sym} 120 -500 0 0 {name=p42 sig_type=std_logic lab=VINN}
C {devices/opin.sym} 100 -440 0 0 {name=p43 sig_type=std_logic lab=DOUT[0:7]}
C {devices/opin.sym} 100 -420 0 0 {name=p44 sig_type=std_logic lab=CKO}
C {devices/lab_wire.sym} 670 -100 0 1 {name=p45 sig_type=std_logic lab=CF[0:7]}
C {devices/ipin.sym} 120 -480 0 0 {name=p37 sig_type=std_logic lab=VCM}
C {devices/lab_wire.sym} 370 -20 0 0 {name=p34 sig_type=std_logic lab=EN}
C {devices/ipin.sym} 120 -460 0 0 {name=p35 sig_type=std_logic lab=EN}
C {devices/lab_wire.sym} 670 -380 0 1 {name=p46 sig_type=std_logic lab=RDY}
C {devices/lab_wire.sym} 370 -100 0 0 {name=p47 sig_type=std_logic lab=CLK}
C {tdc.sym} 520 -380 0 0 {name=x1}
C {sar8b.spice} 500 -110 0 0 {}
C {sar8b.sym} 520 -80 0 0 {name=x4}

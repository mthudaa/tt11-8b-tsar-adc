v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {sky130_stdcells/dfrtp_2.sym} 460 -200 0 0 {name=x2[0:7] VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_wire.sym} 370 -200 0 0 {name=p13 sig_type=std_logic lab=SWP[0:7]}
C {devices/lab_wire.sym} 550 -220 0 1 {name=p14 sig_type=std_logic lab=DOUT[0:7]}
C {devices/lab_wire.sym} 370 -180 0 0 {name=p15 sig_type=std_logic lab=EN}
C {devices/lab_wire.sym} 380 -100 0 0 {name=p16 sig_type=std_logic lab=FINAL}
C {devices/lab_wire.sym} 500 -80 0 1 {name=p18 sig_type=std_logic lab=CK}
C {devices/ipin.sym} 170 -210 0 0 {name=p19 sig_type=std_logic lab=VDD}
C {devices/ipin.sym} 170 -130 0 0 {name=p23 sig_type=std_logic lab=CLKS}
C {devices/ipin.sym} 170 -110 0 0 {name=p24 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 170 -190 0 0 {name=p25 sig_type=std_logic lab=FINAL}
C {devices/ipin.sym} 170 -170 0 0 {name=p26 sig_type=std_logic lab=SWP[0:7]}
C {devices/opin.sym} 170 -70 0 0 {name=p27 sig_type=std_logic lab=DOUT[0:7]}
C {devices/opin.sym} 170 -50 0 0 {name=p28 sig_type=std_logic lab=CK}
C {sky130_stdcells/and2_1.sym} 440 -80 0 0 {name=x3 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/ipin.sym} 170 -150 0 0 {name=p29 sig_type=std_logic lab=EN}
C {devices/lab_wire.sym} 380 -60 0 0 {name=p30 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 370 -220 0 0 {name=p31 sig_type=std_logic lab=CK}

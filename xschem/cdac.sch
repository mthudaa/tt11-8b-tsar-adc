v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/lab_wire.sym} 360 -180 0 0 {name=p1 sig_type=std_logic lab=VCM}
C {devices/lab_wire.sym} 360 -240 0 0 {name=p3 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 360 -160 0 0 {name=p4 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 360 -220 0 0 {name=p6 sig_type=std_logic lab=CF[0:7]}
C {devices/lab_wire.sym} 360 -200 0 0 {name=p7 sig_type=std_logic lab=SWP_IN[0:7]}
C {devices/lab_wire.sym} 360 -70 0 0 {name=p14 sig_type=std_logic lab=SWN_IN[0:7]}
C {devices/lab_wire.sym} 660 -110 0 1 {name=p17 sig_type=std_logic lab=VCN}
C {devices/lab_wire.sym} 660 -240 0 1 {name=p18 sig_type=std_logic lab=VCP}
C {devices/ipin.sym} 160 -230 0 0 {name=p19 sig_type=std_logic lab=VDD}
C {devices/ipin.sym} 160 -190 0 0 {name=p20 sig_type=std_logic lab=VCM}
C {devices/ipin.sym} 160 -210 0 0 {name=p21 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 160 -170 0 0 {name=p22 sig_type=std_logic lab=CF[0:7]}
C {devices/ipin.sym} 160 -150 0 0 {name=p23 sig_type=std_logic lab=SWP_IN[0:7]}
C {devices/ipin.sym} 160 -130 0 0 {name=p24 sig_type=std_logic lab=SWN_IN[0:7]}
C {devices/opin.sym} 160 -110 0 0 {name=p25 sig_type=std_logic lab=VCP}
C {devices/opin.sym} 160 -90 0 0 {name=p26 sig_type=std_logic lab=VCN}
C {single_10b_cdac.sym} 510 -200 0 0 {name=x3}
C {devices/lab_wire.sym} 360 -50 0 0 {name=p27 sig_type=std_logic lab=VCM}
C {devices/lab_wire.sym} 360 -110 0 0 {name=p28 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 360 -30 0 0 {name=p29 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 360 -90 0 0 {name=p30 sig_type=std_logic lab=CF[0:7]}
C {single_10b_cdac.sym} 510 -70 0 0 {name=x4}

v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {sky130_stdcells/dfrtp_1.sym} 700 -410 0 0 {name=x1[0:7] VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/dfrtp_1.sym} 700 -290 0 0 {name=x2[0:7] VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 310 -410 0 0 {name=x6 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/buf_1.sym} 310 -350 0 0 {name=x1 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_wire.sym} 610 -430 0 0 {name=p1 sig_type=std_logic lab=CF[0:7]}
C {devices/lab_wire.sym} 610 -310 0 0 {name=p2 sig_type=std_logic lab=CF[0:7]}
C {devices/lab_wire.sym} 270 -410 0 0 {name=p3 sig_type=std_logic lab=CMP_P}
C {devices/lab_wire.sym} 270 -350 0 0 {name=p4 sig_type=std_logic lab=CMP_N}
C {devices/lab_wire.sym} 350 -410 0 1 {name=p5 sig_type=std_logic lab=CMP_P_BUFF}
C {devices/lab_wire.sym} 350 -350 0 1 {name=p6 sig_type=std_logic lab=CMP_N_BUFF}
C {devices/lab_wire.sym} 610 -410 0 0 {name=p7 sig_type=std_logic lab=CMP_P_BUFF}
C {devices/lab_wire.sym} 610 -290 0 0 {name=p8 sig_type=std_logic lab=CMP_N_BUFF}
C {devices/lab_wire.sym} 610 -270 0 0 {name=p9 sig_type=std_logic lab=CKSB}
C {devices/lab_wire.sym} 610 -390 0 0 {name=p10 sig_type=std_logic lab=CKSB}
C {devices/lab_wire.sym} 790 -430 0 1 {name=p11 sig_type=std_logic lab=SWP[0:7]}
C {devices/lab_wire.sym} 790 -310 0 1 {name=p12 sig_type=std_logic lab=SWN[0:7]}
C {devices/ipin.sym} 100 -420 0 0 {name=p17 sig_type=std_logic lab=VDD}
C {devices/ipin.sym} 100 -400 0 0 {name=p20 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 100 -380 0 0 {name=p21 sig_type=std_logic lab=CF[0:7]}
C {devices/ipin.sym} 100 -360 0 0 {name=p22 sig_type=std_logic lab=CKSB}
C {devices/opin.sym} 80 -300 0 0 {name=p13 sig_type=std_logic lab=SWP[0:7]}
C {devices/opin.sym} 80 -280 0 0 {name=p14 sig_type=std_logic lab=SWN[0:7]}
C {devices/ipin.sym} 100 -340 0 0 {name=p15 sig_type=std_logic lab=CMP_P}
C {devices/ipin.sym} 100 -320 0 0 {name=p16 sig_type=std_logic lab=CMP_N}

v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 80 -460 0 0 {name=p25 sig_type=std_logic lab=VDD}
C {devices/ipin.sym} 80 -440 0 0 {name=p26 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 80 -420 0 0 {name=p27 sig_type=std_logic lab=CLK}
C {devices/ipin.sym} 80 -380 0 0 {name=p30 sig_type=std_logic lab=CMP_P}
C {devices/ipin.sym} 80 -360 0 0 {name=p31 sig_type=std_logic lab=CMP_N}
C {devices/opin.sym} 60 -260 0 0 {name=p32 sig_type=std_logic lab=SWP[0:7]}
C {devices/opin.sym} 60 -240 0 0 {name=p33 sig_type=std_logic lab=SWN[0:7]}
C {devices/opin.sym} 60 -300 0 0 {name=p34 sig_type=std_logic lab=CLKSB}
C {devices/opin.sym} 60 -320 0 0 {name=p35 sig_type=std_logic lab=CLKS}
C {devices/opin.sym} 60 -220 0 0 {name=p36 sig_type=std_logic lab=DOUT[0:7]}
C {devices/opin.sym} 60 -200 0 0 {name=p37 sig_type=std_logic lab=CKO}
C {devices/opin.sym} 60 -280 0 0 {name=p38 sig_type=std_logic lab=CF[0:7]}
C {devices/lab_wire.sym} 280 -390 0 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 280 -130 0 0 {name=p3 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 280 -270 0 0 {name=p4 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 280 -370 0 0 {name=p10 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 280 -30 0 0 {name=p12 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 280 -250 0 0 {name=p13 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 280 -330 0 0 {name=p29 sig_type=std_logic lab=RDY}
C {devices/lab_wire.sym} 280 -310 0 0 {name=p2 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 280 -210 0 0 {name=p5 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 280 -50 0 0 {name=p6 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 580 -370 0 1 {name=p7 sig_type=std_logic lab=FINAL}
C {devices/lab_wire.sym} 280 -110 0 0 {name=p8 sig_type=std_logic lab=FINAL}
C {devices/lab_wire.sym} 280 -190 0 0 {name=p9 sig_type=std_logic lab=CMP_P}
C {devices/lab_wire.sym} 580 -390 0 1 {name=p11 sig_type=std_logic lab=CF[0:7]}
C {devices/lab_wire.sym} 280 -230 0 0 {name=p14 sig_type=std_logic lab=CF[0:7]}
C {devices/lab_wire.sym} 580 -270 0 1 {name=p39 sig_type=std_logic lab=SWP[0:7]}
C {devices/lab_wire.sym} 580 -250 0 1 {name=p40 sig_type=std_logic lab=SWN[0:7]}
C {devices/lab_wire.sym} 280 -90 0 0 {name=p41 sig_type=std_logic lab=SWP[0:7]}
C {devices/lab_wire.sym} 580 -130 0 1 {name=p42 sig_type=std_logic lab=DOUT[0:7]}
C {devices/lab_wire.sym} 580 -110 0 1 {name=p43 sig_type=std_logic lab=CKO}
C {devices/lab_wire.sym} 280 -170 0 0 {name=p15 sig_type=std_logic lab=CMP_N}
C {devices/lab_wire.sym} 280 -70 0 0 {name=p16 sig_type=std_logic lab=EN}
C {devices/lab_wire.sym} 280 -350 0 0 {name=p17 sig_type=std_logic lab=EN}
C {devices/lab_wire.sym} 280 -490 0 0 {name=p18 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 280 -430 0 0 {name=p19 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 280 -470 0 0 {name=p54 sig_type=std_logic lab=CLK}
C {devices/lab_wire.sym} 580 -490 0 1 {name=p55 sig_type=std_logic lab=CLKS}
C {devices/lab_wire.sym} 580 -470 0 1 {name=p56 sig_type=std_logic lab=CLKSB}
C {devices/lab_wire.sym} 280 -450 0 0 {name=p57 sig_type=std_logic lab=EN}
C {auto_sampling.sym} 430 -460 0 0 {name=x2}
C {cyclic_flag.sym} 430 -350 0 0 {name=x1}
C {cdac_ctrl.sym} 430 -220 0 0 {name=x3}
C {out_latch.sym} 430 -80 0 0 {name=x4}
C {devices/ipin.sym} 80 -340 0 0 {name=p20 sig_type=std_logic lab=EN}
C {devices/ipin.sym} 80 -400 0 0 {name=p21 sig_type=std_logic lab=RDY}

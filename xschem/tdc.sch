v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/lab_wire.sym} 540 -220 0 1 {name=p27 sig_type=std_logic lab=OUTN}
C {devices/lab_wire.sym} 540 -240 0 1 {name=p28 sig_type=std_logic lab=OUTP}
C {delay_gate_ori.sym} 390 -470 0 0 {name=x9}
C {devices/lab_wire.sym} 540 -510 0 1 {name=p19 sig_type=std_logic lab=INP}
C {delay_gate_ori.sym} 390 -330 0 0 {name=x10}
C {devices/lab_wire.sym} 540 -370 0 1 {name=p20 sig_type=std_logic lab=INN}
C {devices/lab_wire.sym} 240 -490 0 0 {name=p23 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 240 -350 0 0 {name=p24 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 240 -470 0 0 {name=p25 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 240 -330 0 0 {name=p26 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 240 -450 0 0 {name=p29 sig_type=std_logic lab=VINP}
C {devices/lab_wire.sym} 240 -290 0 0 {name=p30 sig_type=std_logic lab=VINP}
C {devices/lab_wire.sym} 240 -310 0 0 {name=p31 sig_type=std_logic lab=VINN}
C {devices/lab_wire.sym} 240 -430 0 0 {name=p32 sig_type=std_logic lab=VINN}
C {devices/lab_wire.sym} 240 -370 0 0 {name=p33 sig_type=std_logic lab=CLK}
C {devices/lab_wire.sym} 240 -510 0 0 {name=p34 sig_type=std_logic lab=CLK}
C {devices/ipin.sym} 110 -460 0 0 {name=p35 sig_type=std_logic lab=VDD}
C {devices/ipin.sym} 110 -440 0 0 {name=p36 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 110 -420 0 0 {name=p37 sig_type=std_logic lab=VINP}
C {devices/ipin.sym} 110 -400 0 0 {name=p38 sig_type=std_logic lab=VINN}
C {devices/ipin.sym} 110 -480 0 0 {name=p39 sig_type=std_logic lab=CLK}
C {devices/opin.sym} 90 -370 0 0 {name=p40 sig_type=std_logic lab=OUTP}
C {devices/opin.sym} 90 -350 0 0 {name=p41 sig_type=std_logic lab=OUTN}
C {phase_detector.sym} 390 -210 0 0 {name=x1}
C {devices/lab_wire.sym} 240 -240 0 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 240 -220 0 0 {name=p2 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 240 -200 0 0 {name=p3 sig_type=std_logic lab=INP}
C {devices/lab_wire.sym} 240 -180 0 0 {name=p4 sig_type=std_logic lab=INN}
C {devices/opin.sym} 90 -330 0 0 {name=p8 sig_type=std_logic lab=RDY}
C {devices/lab_wire.sym} 540 -200 0 1 {name=p9 sig_type=std_logic lab=RDY}

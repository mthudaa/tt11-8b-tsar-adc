v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {th_sw.sym} 430 -230 0 0 {name=x1}
C {devices/lab_wire.sym} 280 -270 0 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 280 -250 0 0 {name=p2 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 280 -230 0 0 {name=p3 sig_type=std_logic lab=CK_BUFF}
C {devices/lab_wire.sym} 280 -210 0 0 {name=p4 sig_type=std_logic lab=CKB_BUFF}
C {devices/lab_wire.sym} 280 -190 0 0 {name=p5 sig_type=std_logic lab=VIP}
C {devices/lab_wire.sym} 580 -270 0 1 {name=p6 sig_type=std_logic lab=VCP}
C {th_sw.sym} 430 -90 0 0 {name=x2}
C {devices/lab_wire.sym} 280 -130 0 0 {name=p7 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 280 -110 0 0 {name=p8 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 280 -90 0 0 {name=p9 sig_type=std_logic lab=CK_BUFF}
C {devices/lab_wire.sym} 280 -70 0 0 {name=p10 sig_type=std_logic lab=CKB_BUFF}
C {devices/lab_wire.sym} 280 -50 0 0 {name=p11 sig_type=std_logic lab=VIN}
C {devices/lab_wire.sym} 580 -130 0 1 {name=p12 sig_type=std_logic lab=VCN}
C {devices/ipin.sym} 100 -260 0 0 {name=p13 sig_type=std_logic lab=VDD}
C {devices/ipin.sym} 100 -240 0 0 {name=p14 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 100 -220 0 0 {name=p15 sig_type=std_logic lab=CK}
C {devices/ipin.sym} 100 -200 0 0 {name=p16 sig_type=std_logic lab=CKB}
C {devices/ipin.sym} 100 -180 0 0 {name=p17 sig_type=std_logic lab=VIP}
C {devices/ipin.sym} 100 -160 0 0 {name=p18 sig_type=std_logic lab=VIN}
C {devices/opin.sym} 100 -120 0 0 {name=p19 sig_type=std_logic lab=VCP}
C {devices/opin.sym} 100 -100 0 0 {name=p20 sig_type=std_logic lab=VCN}
C {sky130_stdcells/buf_16.sym} 320 -330 0 0 {name=x3 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hs__ }
C {sky130_stdcells/buf_16.sym} 520 -330 0 0 {name=x4 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hs__ }
C {devices/lab_wire.sym} 280 -330 0 0 {name=p21 sig_type=std_logic lab=CK}
C {devices/lab_wire.sym} 480 -330 0 0 {name=p22 sig_type=std_logic lab=CKB}
C {devices/lab_wire.sym} 360 -330 0 1 {name=p23 sig_type=std_logic lab=CK_BUFF}
C {devices/lab_wire.sym} 560 -330 0 1 {name=p24 sig_type=std_logic lab=CKB_BUFF}
C {devices/code_shown.sym} 180 20 0 0 {name=s1 only_toplevel=false value=".include /usr/local/share/pdk/sky130A/libs.ref/sky130_fd_sc_hs/spice/sky130_fd_sc_hs.spice"}

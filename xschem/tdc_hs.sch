v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {delay_gate_ori.sym} 370 -270 0 0 {name=x9}
C {devices/lab_wire.sym} 520 -310 0 1 {name=p19 sig_type=std_logic lab=INP}
C {delay_gate_ori.sym} 370 -110 0 0 {name=x10}
C {devices/lab_wire.sym} 520 -150 0 1 {name=p20 sig_type=std_logic lab=INN}
C {devices/lab_wire.sym} 220 -290 0 0 {name=p23 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 220 -130 0 0 {name=p24 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 220 -270 0 0 {name=p25 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 220 -110 0 0 {name=p26 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 220 -250 0 0 {name=p29 sig_type=std_logic lab=VINP}
C {devices/lab_wire.sym} 220 -70 0 0 {name=p30 sig_type=std_logic lab=VINP}
C {devices/lab_wire.sym} 220 -90 0 0 {name=p31 sig_type=std_logic lab=VINN}
C {devices/lab_wire.sym} 220 -230 0 0 {name=p32 sig_type=std_logic lab=VINN}
C {devices/lab_wire.sym} 220 -150 0 0 {name=p33 sig_type=std_logic lab=CLK}
C {devices/lab_wire.sym} 220 -310 0 0 {name=p34 sig_type=std_logic lab=CLK}
C {pfd.sym} 770 -280 0 0 {name=x1}
C {devices/lab_wire.sym} 620 -310 0 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 620 -290 0 0 {name=p2 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 620 -270 0 0 {name=p3 sig_type=std_logic lab=INP}
C {devices/lab_wire.sym} 620 -250 0 0 {name=p4 sig_type=std_logic lab=INN}
C {devices/lab_wire.sym} 920 -310 0 1 {name=p7 sig_type=std_logic lab=OUTP}
C {devices/lab_wire.sym} 920 -290 0 1 {name=p8 sig_type=std_logic lab=OUTN}
C {sky130_stdcells/or2_1.sym} 730 -100 0 0 {name=x2 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_wire.sym} 670 -120 0 0 {name=p9 sig_type=std_logic lab=INP}
C {devices/lab_wire.sym} 670 -80 0 0 {name=p10 sig_type=std_logic lab=INN}
C {devices/lab_wire.sym} 790 -100 0 1 {name=p11 sig_type=std_logic lab=RDY}
C {devices/ipin.sym} 100 -260 0 0 {name=p35 sig_type=std_logic lab=VDD}
C {devices/ipin.sym} 100 -240 0 0 {name=p36 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 100 -220 0 0 {name=p37 sig_type=std_logic lab=VINP}
C {devices/ipin.sym} 100 -200 0 0 {name=p38 sig_type=std_logic lab=VINN}
C {devices/ipin.sym} 100 -280 0 0 {name=p39 sig_type=std_logic lab=CLK}
C {devices/opin.sym} 80 -170 0 0 {name=p40 sig_type=std_logic lab=OUTP}
C {devices/opin.sym} 80 -150 0 0 {name=p41 sig_type=std_logic lab=OUTN}
C {devices/opin.sym} 80 -130 0 0 {name=p12 sig_type=std_logic lab=RDY}
